# IAR project canary.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsff.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 1024
  General.GHeapSize2: 1024
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: TEST
  ICC430.IExtraOptions: --no_path_in_file_macros
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: test_lnk430fr5739.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: cycle_counter.mac main.c
  group unit_test
    unit_test/: test_uart.c
